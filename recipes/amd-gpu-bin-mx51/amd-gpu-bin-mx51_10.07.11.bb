require amd-gpu.inc
DESCRIPTION = "GPU driver and app for mx51"
