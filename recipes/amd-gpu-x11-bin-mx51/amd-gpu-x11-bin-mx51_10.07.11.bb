require amd-gpu.inc
DESCRIPTION = "GPU driver and app for x11 on mx51"
