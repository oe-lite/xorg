DEFAULT_PREFERENCE = "-1"
require freetype.inc
