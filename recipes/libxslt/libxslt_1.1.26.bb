require libxslt.inc
