include libxcb.inc
PR = "${INC_PR}.0"

SRC_URI = "http://xcb.freedesktop.org/dist/libxcb-${PV}.tar.bz2 \
"

#        file://configure_git.patch"
