require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- keyboard input driver"

PR = "r1"
DEFAULT_PREFERENCE = "-1"
