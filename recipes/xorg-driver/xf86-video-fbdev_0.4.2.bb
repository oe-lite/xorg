require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- fbdev display driver"
PR = "${INC_PR}.0"
