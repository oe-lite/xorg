require libX11.inc
PR = "${INC_PR}.0"
SRC_URI += " file://dolt-fix.patch"
