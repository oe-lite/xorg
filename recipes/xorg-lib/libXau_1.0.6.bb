require xorg-lib-common.inc
DESCRIPTION = "A Sample Authorization Protocol for X"
DEPENDS += " xproto"
PR = "${INC_PR}.0"
BBCLASSEXTEND = "native sdk"
