require xorg-lib-common.inc

DESCRIPTION = "X Fixes extension library."
LICENSE= "BSD-X"
DEPENDS += "libX11${RE}-dev xproto${RE}-dev fixesproto${RE}-dev xextproto${RE}-dev"
