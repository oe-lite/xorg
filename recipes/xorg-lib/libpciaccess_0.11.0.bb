DESCRIPTION = "Generic PCI access library"

require xorg-lib-common.inc

LICENSE = "MIT & MIT-style"

PR = "r0"

DEPENDS += "xproto${RE} libX11${RE}-dev"
