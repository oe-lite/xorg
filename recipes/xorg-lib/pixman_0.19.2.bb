require pixman.inc

EXTRA_OECONF = "--disable-gtk"
