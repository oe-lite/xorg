require xorg-lib-common.inc
DESCRIPTION = "network API translation layer to insulate X applications and \
libraries from OS network vageries."
PR = "${INC_PR}.0"

BBCLASSEXTEND = "native sdk"
