require xorg-proto-common.inc
DESCRIPTION = "DRI2 extension headers"
PR = "${INC_PR}.0"
