require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

BBCLASSEXTEND = "native"
