require xorg-proto-common.inc
PR = "${INC_PR}.0"