require xorg-server-kdrive.inc

PR = "${INC_PR}.0"
