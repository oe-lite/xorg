require xorg-server.inc

PR = "${INC_PR}.0"
